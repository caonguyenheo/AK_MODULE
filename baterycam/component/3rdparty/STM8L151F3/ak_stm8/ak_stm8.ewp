# IAR project ak_stm8.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151F3 STM8L151F3
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 0x1f4
  General.GenHeapSize: 0x10
  ICCSTM8.CCDefines: STM8L15X_LD
  ICCSTM8.CCIncludePath2: ; STM8L15x-16x-05x-AL31-L_StdPeriph_Lib\src; STM8L15x-16x-05x-AL31-L_StdPeriph_Lib\inc; project
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: ak_stm8.hex
  ILINK.IlinkOutputFile: ak_stm8.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDataModel: 1
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    project/: ocv.c
  group drv
    STM8L15x-16x-05x-AL31-L_StdPeriph_Lib/src/: stm8l15x_adc.c stm8l15x_aes.c stm8l15x_beep.c stm8l15x_clk.c stm8l15x_comp.c stm8l15x_dac.c stm8l15x_dma.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_irtim.c stm8l15x_itc.c stm8l15x_iwdg.c stm8l15x_lcd.c stm8l15x_pwr.c stm8l15x_rst.c stm8l15x_rtc.c stm8l15x_spi.c stm8l15x_syscfg.c stm8l15x_tim1.c stm8l15x_tim2.c stm8l15x_tim3.c stm8l15x_tim4.c stm8l15x_tim5.c stm8l15x_usart.c stm8l15x_wfe.c stm8l15x_wwdg.c
  group project
    project/: adc.c adc.h i2c.c i2c.h i2c_software.c main.c stm8l15x_conf.h stm8l15x_it.c stm8l15x_it.h usart1.c usart1.h
